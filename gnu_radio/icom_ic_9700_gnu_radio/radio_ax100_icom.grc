options:
  parameters:
    author: Shu Luo
    copyright: CalgaryToSpace
    generate_options: qt_gui
    id: radio_ax100_icom
    output_language: python
    title: AX100 Radio Link
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: rx_again
  id: variable_qtgui_range
  parameters:
    label: Rx Audio Gain
    start: '0'
    step: '0.1'
    stop: '40'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: audio sample rate
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/baud_rate
  states: {}
- name: tx_again
  id: variable_qtgui_range
  parameters:
    label: Tx Audio Gain
    start: '0'
    step: '0.1'
    stop: '40'
    value: '0'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 10**(tx_again/20)
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: 10**(rx_again/20)
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '4'
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1, 1]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.1'
    max_dev: '1.5'
    nfilters: '32'
    osps: '1'
    pfb_mf_taps: np.ones(32*int(sps))/sps
    resamp_type: digital.IR_PFB_MF
    sps: samp_rate/baud_rate
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: ''
  states: {state: disabled}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 127.0.0.1
    gpredict_port: '7356'
    verbose: 'False'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: samp_rate/baud_rate/4
    type: float
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52002'
    type: TCP_SERVER
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    marker1: '0'
    size: baud_rate
    srate: baud_rate
    style1: '0'
    tr_delay: '0.01'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ylabel: Rx Baseband
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: samp_rate//10
    srate: samp_rate
    type: float
    ylabel: Tx Baseband
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    marker1: '0'
    size: baud_rate
    srate: baud_rate
    style1: '0'
    tr_delay: '0.01'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ylabel: Rx Baseband
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: satellites_ax100_deframer_0
  id: satellites_ax100_deframer
  parameters:
    mode: '"ASM"'
    scrambler: '"CCSDS"'
    threshold: '1'
  states: {}

connections:
- [audio_source_0, '0', blocks_multiply_const_xx_0_0, '0']
- [blocks_multiply_const_xx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_xx_0_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_multiply_const_xx_0_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_repeat_0, '0', blocks_tag_debug_0, '0']
- [blocks_repeat_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_repeat_0, '0', epy_block_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_repeat_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', mmse_resampler_xx_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_symbol_sync_xx_0, '0', satellites_ax100_deframer_0, '0']
- [mmse_resampler_xx_0, '0', blocks_multiply_const_xx_0, '0']
- [mmse_resampler_xx_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [network_socket_pdu_0, pdus, blocks_message_debug_0_0, print]
- [network_socket_pdu_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [satellites_ax100_deframer_0, out, blocks_message_debug_0, print]
- [satellites_ax100_deframer_0, out, network_socket_pdu_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.6.0
