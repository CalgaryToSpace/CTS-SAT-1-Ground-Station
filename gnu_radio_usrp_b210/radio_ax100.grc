options:
  parameters:
    author: Shu Luo
    copyright: CalgaryToSpace
    generate_options: qt_gui
    id: radio_ax100
    output_language: python
    title: AX100 Radio Link
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: bw
  id: variable
  parameters:
    comment: =freq_uncertainty+2*fdev+baud_rate
    value: freq_uncertainty+2*fdev+baud_rate
  states: {}
- name: ddc_actual_taps
  id: variable
  parameters:
    value: len(ddc_taps)/ratio
  states: {}
- name: ddc_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: bw/2
    gain: '1.0'
    samp_rate: samp_rate
    width: bw/2*0.2
    win: window.WIN_HAMMING
  states: {}
- name: duc_actual_taps
  id: variable
  parameters:
    value: len(duc_taps)/ratio
  states: {}
- name: duc_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: iq_rate/2
    gain: '1.0'
    samp_rate: samp_rate
    width: iq_rate/2*0.2
    win: window.WIN_HAMMING
  states: {}
- name: fdev
  id: variable
  parameters:
    value: baud_rate/4
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: (0,0,1,1)
    label: Freq
    start: 430e6
    step: 1e2
    stop: 440e6
    value: 436.15e6
  states: {}
- name: freq_uncertainty
  id: variable
  parameters:
    value: 20e3
  states: {}
- name: iq_rate
  id: variable
  parameters:
    comment: =samp_rate/ratio
    value: samp_rate/ratio
  states: {}
- name: ratio
  id: variable
  parameters:
    comment: =ceilpow2(samp_rate/max(bw, baud_rate))
    value: 2**int(math.log2(samp_rate/max(bw, baud_rate)))
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,0,1,1)
    label: Rx Gain
    start: '0'
    step: '1'
    stop: '76'
    value: '65'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: max_baud*4
    value: 115200*4
  states: {}
- name: sps
  id: variable
  parameters:
    comment: make sure it's a integer
    value: iq_rate/baud_rate
  states: {}
- name: tx_pwr
  id: variable_qtgui_range
  parameters:
    gui_hint: (2,0,1,1)
    label: Tx Power
    start: '-10'
    step: '0.1'
    stop: '13'
    value: '0'
  states: {}
- name: tx_pwr_cal
  id: variable
  parameters:
    comment: for usrp b210
    value: '65.5'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*math.pi*fdev/iq_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(sps)
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1, 1]'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: samp_rate/4
    decim: ratio
    samp_rate: samp_rate
    taps: ddc_taps
    type: ccc
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 127.0.0.1
    gpredict_port: '7356'
    verbose: 'False'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: ratio
    taps: duc_taps
    type: ccc
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq-samp_rate/4
    fftsize: '1024'
    grid: 'True'
    gui_hint: (3,0,1,1)
    label: Amplitude
    norm_window: 'True'
    type: complex
    wintype: window.WIN_FLATTOP
    ymax: '-40'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: (5,0,1,1)
    label: Amplitude
    norm_window: 'True'
    type: complex
    wintype: window.WIN_FLATTOP
    ymin: '-50'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: (6,0,1,1)
    size: '1024'
    srate: iq_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (4,0,1,1)
    size: baud_rate//10
    srate: baud_rate
    type: float
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: satellites_ax100_deframer_0
  id: satellites_ax100_deframer
  parameters:
    mode: '"ASM"'
    scrambler: '"CCSDS"'
    threshold: '1'
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: baud_rate
    iq: 'True'
    samp_rate: iq_rate
    subaudio: 'False'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    gain0: tx_pwr+tx_pwr_cal
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq-samp_rate/4
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', interp_fir_filter_xxx_0, '0']
- [analog_frequency_modulator_fc_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_repeat_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_repeat_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', analog_frequency_modulator_fc_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', satellites_fsk_demodulator_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [interp_fir_filter_xxx_0, '0', uhd_usrp_sink_0, '0']
- [network_socket_pdu_0, pdus, blocks_message_debug_0_0, print]
- [network_socket_pdu_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [satellites_ax100_deframer_0, out, blocks_message_debug_0, print]
- [satellites_ax100_deframer_0, out, network_socket_pdu_0, pdus]
- [satellites_fsk_demodulator_0, '0', qtgui_time_sink_x_0_0, '0']
- [satellites_fsk_demodulator_0, '0', satellites_ax100_deframer_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
